# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302x8 ST STM32F302x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F302x8
  ICCARM.CCIncludePath2: ..; ..\..\chibios191\os\license; ..\..\chibios191\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\chibios191\os\common\ext\ARM\CMSIS\Core\Include; ..\..\chibios191\os\common\ext\ST\STM32F3xx; ..\..\chibios191\os\common\ports\ARMCMx; ..\..\chibios191\os\common\ports\ARMCMx\compilers\IAR; ..\..\chibios191\os\oslib\include; ..\..\chibios191\os\rt\include; ..\..\chibios191\os\hal\osal\rt; ..\..\chibios191\os\hal\include; ..\..\chibios191\os\hal\ports\common\ARMCMx; ..\..\chibios191\os\hal\ports\STM32\STM32F3xx; ..\..\chibios191\os\hal\ports\STM32\LLD\ADCv3; ..\..\chibios191\os\hal\ports\STM32\LLD\CANv1; ..\..\chibios191\os\hal\ports\STM32\LLD\DMAv1; ..\..\chibios191\test\lib; ..\..\chibios191\test\rt\source\test; ..\Inc; ..\..\chibios191\os\hal\ports\STM32\LLD\EXTIv1; ..\..\chibios191\os\hal\ports\STM32\LLD\GPIOv2; ..\..\chibios191\os\hal\ports\STM32\LLD\I2Cv2; ..\..\chibios191\os\hal\ports\STM32\LLD\RTCv2; ..\..\chibios191\os\hal\ports\STM32\LLD\SPIv2; ..\..\chibios191\os\hal\ports\STM32\LLD\TIMv1; ..\..\chibios191\os\hal\ports\STM32\LLD\USARTv2; ..\..\chibios191\os\hal\ports\STM32\LLD\USBv1; ..\..\chibios191\os\hal\ports\STM32\LLD\xWDGv1; ..\..\chibios191\test\oslib\source\test; ..\..\chibios191\os\common\startup\ARMCMx\compilers\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\Inc; ..\..\chibios191\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\chibios191\os\common\ports\ARMCMx; ..\..\chibios191\os\common\ports\ARMCMx\compilers\IAR; ..\..\chibios191\os\oslib\include; D:\Chibios_Sandbox\chibios191\os\license
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ext\CMSIS\include; ..\..\..\..\os\common\ext\CMSIS\ST\STM32F3xx; ..\..\..\..\os\common\ports\ARMCMx; ..\..\..\..\os\common\ports\ARMCMx\compilers\IAR; ..\..\..\..\os\common\oslib\include; ..\..\..\..\os\rt\include; ..\..\..\..\os\hal\osal\rt; ..\..\..\..\os\hal\include; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY; ..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\os\hal\ports\STM32\STM32F3xx; ..\..\..\..\os\hal\ports\STM32\LLD\ADCv3; ..\..\..\..\os\hal\ports\STM32\LLD\CANv1; ..\..\..\..\os\hal\ports\STM32\LLD\DMAv1; ..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1; ..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2; ..\..\..\..\os\hal\ports\STM32\LLD\RTCv2; ..\..\..\..\os\hal\ports\STM32\LLD\SPIv2; ..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\os\hal\ports\STM32\LLD\USARTv2; ..\..\..\..\os\hal\ports\STM32\LLD\USBv1; ..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1; ..\..\..\..\test\lib; ..\..\..\..\test\rt\source\test
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ports\ARMCMx
  group (top)
    ../: main.c
  group board
    ../Src/: board.c
    ../Inc/: board.h
  group conf
    ../Inc/: chconf.h halconf.h mcuconf.h
  group os/common
    ../../chibios191/os/common/ports/ARMCMx/: chcore.c chcore_v7m.c
    ../../chibios191/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v7m.s
    ../../chibios191/os/hal/ports/common/ARMCMx/: nvic.c
  group os/common/oslib/src
    ../../chibios191/os/oslib/src/: chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chpipes.c
  group os/common/startup
    ../../chibios191/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group os/ext/CMSIS
    ../../chibios191/os/common/abstractions/cmsis_os/: cmsis_os.c
  group os/hal/lib/streams
    ../../chibios191/os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c streams.mk
  group os/hal/port
    ../../chibios191/os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_spi_lld.c
    ../../chibios191/os/hal/ports/STM32/STM32F3xx/: hal_lld.c platform.mk stm32_isr.c
    ../../chibios191/os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_uart_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c
    ../../chibios191/os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c
    ../../chibios191/os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c
  group os/hal/src
    ../../chibios191/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group os/rt/src
    ../../chibios191/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group os/various
    ../../chibios191/os/various/: evtimer.c
  group test/lib
    ../../chibios191/test/lib/: ch_test.c ch_test.h
  group test/source
    ../../chibios191/test/oslib/source/test/: oslib_test_root.c oslib_test_root.h oslib_test_sequence_001.c oslib_test_sequence_002.c oslib_test_sequence_003.c oslib_test_sequence_004.c oslib_test_sequence_005.c
    ../../chibios191/test/rt/source/test/: rt_test_root.c rt_test_sequence_001.c rt_test_sequence_002.c rt_test_sequence_003.c rt_test_sequence_004.c rt_test_sequence_005.c rt_test_sequence_006.c rt_test_sequence_007.c rt_test_sequence_008.c rt_test_sequence_009.c rt_test_sequence_010.c
